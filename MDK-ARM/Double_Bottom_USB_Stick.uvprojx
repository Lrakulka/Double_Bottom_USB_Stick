# Keil uVision project Double_Bottom_USB_Stick.uvprojx, settings and files
target Double_Bottom_USB_Stick (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Double_Bottom_USB_Stick
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c misc: --C99
  c include: ../Inc;                                                    ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;                                                    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                    ../Drivers/CMSIS/Include;     ../Middlewares/Third_Party/FatFs/src/drivers;     ../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_scsi.c usbd_msc_data.c usbd_msc.c usbd_msc_bot.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c usbd_desc.c usbd_conf.c stm32f4xx_hal_msp.c usbd_storage_if.c usb_device.c fatfs.c bsp_driver_sd.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_cortex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/Double_Bottom_USB_Stick
    ../Src/: sd_io_controller.c
software components: CMSIS:CORE 4.1.0
